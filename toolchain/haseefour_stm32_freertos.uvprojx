# Keil uVision project haseefour_stm32_freertos.uvprojx, settings and files
target stm32_freertos (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: haseefour_stm32_freertos +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\src;..\src\app;..\src\drivers\bsp;..\src\drivers\mcu;..\src\protocol;..\src\rtos\freertos9_0_0\Source\include;..\src\rtos\freertos9_0_0\Source\portable\RVDS\ARM_CM3;..\src\rtos\freertos9_0_0;..\src\utils;..\src\rtos\FreeRTOS-Plus-TCP;..\src\rtos\FreeRTOS-Plus-TCP\include;..\toolchain;..\src\protocol\modbus;..\src\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../src/: main.c nvic.c stm32f10x_it.c
  group utils
    ../src/utils/: global.c
  group app
    ../src/app/: app.c task_led_toggle.c task_modbus_process.c
  group mcu
    ../src/drivers/mcu/: usart.c spi.c
  group bsp
    ../src/drivers/bsp/: led.c w25x16.c i2c_ee.c
  group rtos
    ../src/rtos/freertos9_0_0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../src/rtos/freertos9_0_0/Source/portable/MemMang/: heap_4.c
    ../src/rtos/freertos9_0_0/Source/portable/RVDS/ARM_CM3/: port.c
  group fatfs
    ../src/fatfs/: ff.c diskio.c
    ../src/fatfs/option/: cc936.c
  group modbus
    ../src/protocol/modbus/: modbus.c modbus_slave.c
  group doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
